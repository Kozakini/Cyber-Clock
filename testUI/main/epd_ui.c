#include "epd_ui.h"
#include <string.h>
#include <stdio.h>
#include <math.h>

// ============================================================
//  Bufor ekranu
// ============================================================
uint8_t canvas[FULL_SIZE];

// ============================================================
//  Prymitywy rysowania
// ============================================================
void ui_fill(uint8_t white) {
    memset(canvas, white ? 0xFF : 0x00, FULL_SIZE);
}

void ui_px(int x, int y, uint8_t white) {
    if (x < 0 || x >= EPD_W || y < 0 || y >= EPD_H) return;
    int b = y * FULL_W_BYTES + (x >> 3);
    int k = 7 - (x & 7);
    if (white) canvas[b] |=  (1 << k);
    else       canvas[b] &= ~(1 << k);
}

void ui_hline(int x, int y, int len, uint8_t white) {
    for (int i = x; i < x + len; i++) ui_px(i, y, white);
}

void ui_vline(int x, int y, int len, uint8_t white) {
    for (int i = y; i < y + len; i++) ui_px(x, i, white);
}

void ui_rect_fill(int x, int y, int w, int h, uint8_t white) {
    for (int row = y; row < y + h; row++)
        ui_hline(x, row, w, white);
}

void ui_rect_border(int x, int y, int w, int h, uint8_t white) {
    ui_hline(x, y,         w, white);
    ui_hline(x, y + h - 1, w, white);
    ui_vline(x,         y, h, white);
    ui_vline(x + w - 1, y, h, white);
}

// ============================================================
//  Czcionka 8x8 — każdy glif: w=szerokość px, rows=8 wierszy
//  Bity w rows: bit7=lewy piksel, używamy zawsze 8 bitów
//  w określa tylko odstęp między znakami (kerning)
// ============================================================
typedef struct { uint8_t w; uint8_t rows[8]; } Glyph;

static const Glyph FONT[256] = {
    [' '] = {4,  {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}},
    ['!'] = {2,  {0xC0,0xC0,0xC0,0xC0,0x00,0x00,0xC0,0x00}},
    ['"'] = {4,  {0xA0,0xA0,0x00,0x00,0x00,0x00,0x00,0x00}},
    ['#'] = {6,  {0x28,0x28,0xFC,0x28,0xFC,0x28,0x28,0x00}},
    ['%'] = {6,  {0x60,0x92,0x64,0x08,0x10,0x26,0x46,0x00}},
    ['&'] = {6,  {0x38,0x6C,0x68,0x70,0xED,0xC6,0x7B,0x00}},
    ['('] = {3,  {0x20,0x40,0x40,0x40,0x40,0x40,0x20,0x00}},
    [')'] = {3,  {0x40,0x20,0x20,0x20,0x20,0x20,0x40,0x00}},
    ['+'] = {5,  {0x00,0x20,0x20,0xF8,0x20,0x20,0x00,0x00}},
    [','] = {2,  {0x00,0x00,0x00,0x00,0x00,0xC0,0x80,0x40}},
    ['-'] = {4,  {0x00,0x00,0x00,0xF0,0x00,0x00,0x00,0x00}},
    ['.'] = {2,  {0x00,0x00,0x00,0x00,0x00,0xC0,0xC0,0x00}},
    ['/'] = {4,  {0x10,0x10,0x20,0x20,0x40,0x40,0x80,0x00}},
    ['0'] = {6,  {0x78,0xCC,0xDC,0xEC,0xCC,0xCC,0x78,0x00}},
    ['1'] = {3,  {0x60,0xE0,0x60,0x60,0x60,0x60,0xF0,0x00}},
    ['2'] = {6,  {0x78,0xCC,0x0C,0x18,0x30,0x60,0xFC,0x00}},
    ['3'] = {6,  {0x78,0xCC,0x0C,0x38,0x0C,0xCC,0x78,0x00}},
    ['4'] = {6,  {0x0C,0x1C,0x3C,0x6C,0xFC,0x0C,0x0C,0x00}},
    ['5'] = {6,  {0xFC,0xC0,0xF8,0x0C,0x0C,0xCC,0x78,0x00}},
    ['6'] = {6,  {0x78,0xC0,0xF8,0xCC,0xCC,0xCC,0x78,0x00}},
    ['7'] = {6,  {0xFC,0x0C,0x18,0x30,0x60,0x60,0x60,0x00}},
    ['8'] = {6,  {0x78,0xCC,0xCC,0x78,0xCC,0xCC,0x78,0x00}},
    ['9'] = {6,  {0x78,0xCC,0xCC,0x7C,0x0C,0x18,0x70,0x00}},
    [':'] = {2,  {0x00,0xC0,0xC0,0x00,0xC0,0xC0,0x00,0x00}},
    [';'] = {2,  {0x00,0xC0,0xC0,0x00,0xC0,0x80,0x40,0x00}},
    ['<'] = {4,  {0x10,0x20,0x40,0x80,0x40,0x20,0x10,0x00}},
    ['='] = {5,  {0x00,0x00,0xF8,0x00,0xF8,0x00,0x00,0x00}},
    ['>'] = {4,  {0x80,0x40,0x20,0x10,0x20,0x40,0x80,0x00}},
    ['?'] = {5,  {0x70,0x88,0x08,0x30,0x20,0x00,0x20,0x00}},
    ['@'] = {7,  {0x7C,0xC6,0xDE,0xDE,0xDE,0xC0,0x78,0x00}},
    ['A'] = {6,  {0x30,0x78,0xCC,0xFC,0xCC,0xCC,0xCC,0x00}},
    ['B'] = {6,  {0xF8,0xCC,0xCC,0xF8,0xCC,0xCC,0xF8,0x00}},
    ['C'] = {6,  {0x78,0xCC,0xC0,0xC0,0xC0,0xCC,0x78,0x00}},
    ['D'] = {6,  {0xF0,0xD8,0xCC,0xCC,0xCC,0xD8,0xF0,0x00}},
    ['E'] = {5,  {0xF8,0xC0,0xC0,0xF0,0xC0,0xC0,0xF8,0x00}},
    ['F'] = {5,  {0xF8,0xC0,0xC0,0xF0,0xC0,0xC0,0xC0,0x00}},
    ['G'] = {6,  {0x78,0xCC,0xC0,0xDC,0xCC,0xCC,0x78,0x00}},
    ['H'] = {6,  {0xCC,0xCC,0xCC,0xFC,0xCC,0xCC,0xCC,0x00}},
    ['I'] = {3,  {0xE0,0x40,0x40,0x40,0x40,0x40,0xE0,0x00}},
    ['J'] = {5,  {0x38,0x18,0x18,0x18,0x18,0xD8,0x70,0x00}},
    ['K'] = {6,  {0xCC,0xD8,0xF0,0xE0,0xF0,0xD8,0xCC,0x00}},
    ['L'] = {5,  {0xC0,0xC0,0xC0,0xC0,0xC0,0xC0,0xF8,0x00}},
    ['M'] = {7,  {0xC6,0xEE,0xFE,0xD6,0xC6,0xC6,0xC6,0x00}},
    ['N'] = {6,  {0xCC,0xEC,0xFC,0xDC,0xCC,0xCC,0xCC,0x00}},
    ['O'] = {6,  {0x78,0xCC,0xCC,0xCC,0xCC,0xCC,0x78,0x00}},
    ['P'] = {6,  {0xF8,0xCC,0xCC,0xF8,0xC0,0xC0,0xC0,0x00}},
    ['Q'] = {6,  {0x78,0xCC,0xCC,0xCC,0xDC,0x78,0x1C,0x00}},
    ['R'] = {6,  {0xF8,0xCC,0xCC,0xF8,0xD8,0xCC,0xCC,0x00}},
    ['S'] = {6,  {0x78,0xCC,0xC0,0x78,0x0C,0xCC,0x78,0x00}},
    ['T'] = {5,  {0xF8,0x20,0x20,0x20,0x20,0x20,0x20,0x00}},
    ['U'] = {6,  {0xCC,0xCC,0xCC,0xCC,0xCC,0xCC,0x78,0x00}},
    ['V'] = {6,  {0xCC,0xCC,0xCC,0xCC,0xCC,0x78,0x30,0x00}},
    ['W'] = {7,  {0xC6,0xC6,0xC6,0xD6,0xFE,0xEE,0xC6,0x00}},
    ['X'] = {6,  {0xCC,0xCC,0x78,0x30,0x78,0xCC,0xCC,0x00}},
    ['Y'] = {5,  {0xC8,0xC8,0xD0,0x20,0x20,0x20,0x20,0x00}},
    ['Z'] = {6,  {0xFC,0x0C,0x18,0x30,0x60,0xC0,0xFC,0x00}},
    ['a'] = {5,  {0x00,0x00,0x78,0x18,0x78,0xD8,0x78,0x00}},
    ['b'] = {5,  {0xC0,0xC0,0xF8,0xCC,0xCC,0xCC,0xF8,0x00}},
    ['c'] = {5,  {0x00,0x00,0x78,0xC0,0xC0,0xD8,0x78,0x00}},
    ['d'] = {5,  {0x18,0x18,0x78,0xD8,0xD8,0xD8,0x78,0x00}},
    ['e'] = {5,  {0x00,0x00,0x78,0xCC,0xFC,0xC0,0x78,0x00}},
    ['f'] = {4,  {0x30,0x60,0xF0,0x60,0x60,0x60,0x60,0x00}},
    ['g'] = {5,  {0x00,0x00,0x78,0xCC,0xCC,0x78,0x18,0x70}},
    ['h'] = {5,  {0xC0,0xC0,0xF8,0xCC,0xCC,0xCC,0xCC,0x00}},
    ['i'] = {2,  {0xC0,0x00,0xC0,0xC0,0xC0,0xC0,0xC0,0x00}},
    ['j'] = {3,  {0x60,0x00,0x60,0x60,0x60,0x60,0xC0,0x00}},
    ['k'] = {5,  {0xC0,0xC0,0xCC,0xD8,0xF0,0xD8,0xCC,0x00}},
    ['l'] = {2,  {0xC0,0xC0,0xC0,0xC0,0xC0,0xC0,0xC0,0x00}},
    ['m'] = {7,  {0x00,0x00,0xEC,0xFE,0xD6,0xC6,0xC6,0x00}},
    ['n'] = {5,  {0x00,0x00,0xF8,0xCC,0xCC,0xCC,0xCC,0x00}},
    ['o'] = {5,  {0x00,0x00,0x78,0xCC,0xCC,0xCC,0x78,0x00}},
    ['p'] = {5,  {0x00,0x00,0xF8,0xCC,0xCC,0xF8,0xC0,0xC0}},
    ['q'] = {5,  {0x00,0x00,0x78,0xCC,0xCC,0x78,0x18,0x18}},
    ['r'] = {4,  {0x00,0x00,0xD0,0xE0,0xC0,0xC0,0xC0,0x00}},
    ['s'] = {5,  {0x00,0x00,0x78,0xC0,0x78,0x18,0xF8,0x00}},
    ['t'] = {4,  {0x60,0x60,0xF0,0x60,0x60,0x60,0x30,0x00}},
    ['u'] = {5,  {0x00,0x00,0xCC,0xCC,0xCC,0xCC,0x78,0x00}},
    ['v'] = {5,  {0x00,0x00,0xCC,0xCC,0xCC,0x78,0x30,0x00}},
    ['w'] = {7,  {0x00,0x00,0xC6,0xC6,0xD6,0xFE,0x6C,0x00}},
    ['x'] = {5,  {0x00,0x00,0xCC,0x78,0x30,0x78,0xCC,0x00}},
    ['y'] = {5,  {0x00,0x00,0xCC,0xCC,0xCC,0x78,0x30,0x60}},
    ['z'] = {5,  {0x00,0x00,0xF8,0x18,0x30,0x60,0xF8,0x00}},
    // stopien: 0xB0 (obslugiwany przez dekoder UTF-8 dla C2 B0)
    [0xB0] = {4, {0x60,0x90,0x90,0x60,0x00,0x00,0x00,0x00}},
};

// ============================================================
//  Rysowanie jednego glifа — zawsze iteruje po 8 bitach
// ============================================================
static void draw_glyph(int x, int y, uint8_t idx, int scale, uint8_t white) {
    if (FONT[idx].w == 0) return;
    const Glyph *g = &FONT[idx];
    for (int row = 0; row < 8; row++) {
        for (int col = 0; col < 8; col++) {
            if (g->rows[row] & (0x80 >> col)) {
                for (int sy = 0; sy < scale; sy++)
                    for (int sx = 0; sx < scale; sx++)
                        ui_px(x + col*scale + sx, y + row*scale + sy, white);
            }
        }
    }
}

// ============================================================
//  Wypisz tekst — obsługa UTF-8 dla znaku stopnia °
// ============================================================
void ui_text(int x, int y, const char *s, int scale, uint8_t white) {
    while (*s) {
        uint8_t idx = (uint8_t)*s;

        // UTF-8: stopień ° = 0xC2 0xB0
        if (idx == 0xC2 && (uint8_t)s[1] == 0xB0) {
            draw_glyph(x, y, 0xB0, scale, white);
            x += (FONT[0xB0].w + 1) * scale;
            s += 2;
            continue;
        }

        // Pomiń inne bajty UTF-8 > 0x7F
        if (idx > 0x7F) { s++; continue; }

        if (FONT[idx].w > 0) {
            draw_glyph(x, y, idx, scale, white);
            x += (FONT[idx].w + 1) * scale;
        } else {
            x += 5 * scale; // nieznany znak = spacja
        }
        s++;
    }
}

int ui_text_width(const char *s, int scale) {
    int w = 0;
    while (*s) {
        uint8_t idx = (uint8_t)*s;
        if (idx == 0xC2 && (uint8_t)s[1] == 0xB0) {
            w += (FONT[0xB0].w + 1) * scale;
            s += 2; continue;
        }
        if (idx > 0x7F) { s++; continue; }
        w += (FONT[idx].w > 0 ? FONT[idx].w + 1 : 5) * scale;
        s++;
    }
    return w > 0 ? w - scale : 0;
}

// ============================================================
//  Ikony pogody — wektorowe prymitywami
// ============================================================
static void draw_circle_fill(int cx, int cy, int r, uint8_t white) {
    for (int dy = -r; dy <= r; dy++)
        for (int dx = -r; dx <= r; dx++)
            if (dx*dx + dy*dy <= r*r)
                ui_px(cx+dx, cy+dy, white);
}

static void draw_circle_outline(int cx, int cy, int r, uint8_t white) {
    int x = r, y = 0, err = 0;
    while (x >= y) {
        ui_px(cx+x,cy+y,white); ui_px(cx+y,cy+x,white);
        ui_px(cx-y,cy+x,white); ui_px(cx-x,cy+y,white);
        ui_px(cx-x,cy-y,white); ui_px(cx-y,cy-x,white);
        ui_px(cx+y,cy-x,white); ui_px(cx+x,cy-y,white);
        y++;
        err += 1 + 2*y;
        if (2*(err-x)+1 > 0) { x--; err += 1-2*x; }
    }
}

void ui_weather_icon(int x, int y, int size, weather_icon_t icon) {
    // Rysuj ikonę jako bitmapę 32x32 skalowaną do size
    // scale = size/32
    int sc = size / 32;
    if (sc < 1) sc = 1;

    // Chmura 32x32 — mapa bitowa wiersz po wierszu
    static const uint8_t CLOUD[32][4] = {
        {0x00,0x00,0x00,0x00},
        {0x00,0x00,0x00,0x00},
        {0x00,0x3C,0x00,0x00},
        {0x00,0xFF,0x00,0x00},
        {0x03,0xFF,0xC0,0x00},
        {0x07,0xFF,0xE0,0x00},
        {0x0F,0xFF,0xF0,0x00},
        {0x1F,0xFF,0xF8,0x00},
        {0xFF,0xFF,0xFF,0x00},
        {0xFF,0xFF,0xFF,0x00},
        {0xFF,0xFF,0xFF,0x00},
        {0xFF,0xFF,0xFF,0x00},
        {0x7F,0xFF,0xFE,0x00},
        {0x3F,0xFF,0xFC,0x00},
        {0x00,0x00,0x00,0x00},
        {0x00,0x00,0x00,0x00},
    };

    static const uint8_t SUN[32][4] = {
        {0x00,0x18,0x00,0x00},
        {0x10,0x18,0x08,0x00},
        {0x08,0x00,0x10,0x00},
        {0x00,0x00,0x00,0x00},
        {0x01,0x7E,0x80,0x00},
        {0x20,0xFF,0x04,0x00},
        {0x20,0xFF,0x04,0x00},
        {0x60,0xFF,0x06,0x00},
        {0x7F,0xFF,0xFE,0x00},
        {0x7F,0xFF,0xFE,0x00},
        {0x60,0xFF,0x06,0x00},
        {0x20,0xFF,0x04,0x00},
        {0x20,0xFF,0x04,0x00},
        {0x01,0x7E,0x80,0x00},
        {0x00,0x00,0x00,0x00},
        {0x08,0x00,0x10,0x00},
        {0x10,0x18,0x08,0x00},
        {0x00,0x18,0x00,0x00},
    };

    static const uint8_t RAIN[32][4] = {
        {0x00,0x3C,0x00,0x00},
        {0x00,0xFF,0x00,0x00},
        {0x03,0xFF,0xC0,0x00},
        {0x0F,0xFF,0xF0,0x00},
        {0xFF,0xFF,0xFF,0x00},
        {0xFF,0xFF,0xFF,0x00},
        {0x3F,0xFF,0xFC,0x00},
        {0x00,0x00,0x00,0x00},
        {0x44,0x44,0x44,0x00},
        {0x22,0x22,0x22,0x00},
        {0x44,0x44,0x44,0x00},
        {0x22,0x22,0x22,0x00},
        {0x44,0x44,0x44,0x00},
        {0x00,0x00,0x00,0x00},
    };

    static const uint8_t SNOW[32][4] = {
        {0x00,0x3C,0x00,0x00},
        {0x00,0xFF,0x00,0x00},
        {0x03,0xFF,0xC0,0x00},
        {0x0F,0xFF,0xF0,0x00},
        {0xFF,0xFF,0xFF,0x00},
        {0xFF,0xFF,0xFF,0x00},
        {0x3F,0xFF,0xFC,0x00},
        {0x00,0x00,0x00,0x00},
        {0x49,0x24,0x92,0x00},
        {0x22,0x91,0x44,0x00},
        {0x49,0x24,0x92,0x00},
        {0x22,0x91,0x44,0x00},
        {0x00,0x00,0x00,0x00},
    };

    const uint8_t (*bitmap)[4] = NULL;
    int rows = 0;

    switch (icon) {
        case WEATHER_SUNNY:  bitmap = SUN;   rows = 18; break;
        case WEATHER_CLOUDY: bitmap = CLOUD; rows = 14; break;
        case WEATHER_RAIN:   bitmap = RAIN;  rows = 14; break;
        case WEATHER_SNOW:   bitmap = SNOW;  rows = 13; break;
        default:             bitmap = CLOUD; rows = 14; break;
    }

    if (!bitmap) return;

    for (int row = 0; row < rows; row++) {
        for (int col = 0; col < 32; col++) {
            int byte_idx = col / 8;
            int bit_idx  = 7 - (col % 8);
            if ((bitmap[row][byte_idx] >> bit_idx) & 1) {
                for (int sy = 0; sy < sc; sy++)
                    for (int sx = 0; sx < sc; sx++)
                        ui_px(x + col*sc + sx, y + row*sc + sy, 0);
            }
        }
    }
}
// ============================================================
//  Rysowanie BMP 1-bit (bit7 = lewy piksel)
// ============================================================
void ui_bmp(int x, int y, int w, int h, const uint8_t *buf) {
    if (!buf) return;
    int row_bytes = (w + 7) / 8;
    for (int row = 0; row < h; row++)
        for (int col = 0; col < w; col++) {
            uint8_t bit = (buf[row * row_bytes + (col >> 3)] >> (7 - (col & 7))) & 1;
            ui_px(x + col, y + row, bit);
        }
}
void ui_text_wrap(int x, int y, const char *s, int scale, int max_width, uint8_t white) {
    char word[32];
    int cx = x;
    int cy = y;
    int line_h = 8 * scale + 3;

    while (*s) {
        // Zbierz jedno słowo
        int wi = 0;
        while (*s && *s != ' ' && wi < 31)
            word[wi++] = *s++;
        word[wi] = '\0';
        if (*s == ' ') s++;

        int ww = ui_text_width(word, scale);

        // Czy słowo się mieści w bieżącej linii?
        if (cx > x && cx + ww > x + max_width) {
            cx = x;
            cy += line_h;
        }

        ui_text(cx, cy, word, scale, white);
        cx += ww + (FONT[' '].w + 1) * scale;
    }
}
// ============================================================
//  Nazwy
// ============================================================
static const char *DAYS[]   = {"Nd","Pn","Wt","Sr","Cz","Pt","So"};
static const char *MONTHS[] = {
    "sty","lut","mar","kwi","maj","cze",
    "lip","sie","wrz","paz","lis","gru"
};

// ============================================================
//  Główna funkcja rysowania UI
// ============================================================
void ui_draw(const ui_time_t *t, const ui_weather_t *w,
             const uint8_t *bmp_buf, int bmp_w, int bmp_h)
{
    ui_fill(1); // białe tło

    // ----------------------------------------------------------
    // STREFA LEWA: godzina + data
    // ----------------------------------------------------------
    {
        char hstr[6];
        snprintf(hstr, sizeof(hstr), "%02d:%02d", t->hour, t->minute);
        int hscale = 9;
        int hx = MARGIN;
        int hy = EPD_H/2 - 8*hscale/2 - 16;
        ui_text(hx, hy, hstr, hscale, 0);

        char dstr[40];
        snprintf(dstr, sizeof(dstr), "%s %02d %s %04d",
                 DAYS[t->weekday % 7], t->day,
                 MONTHS[(t->month - 1) % 12], t->year);
        int dscale = 2;
        int dy = hy + 8*hscale + 10;
        ui_text(hx, dy, dstr, dscale, 0);

        ui_vline(ZONE_TIME_W - 1, MARGIN, EPD_H - 2*MARGIN, 0);
    }

    // ----------------------------------------------------------
    // STREFA ŚRODKOWA: pogoda
    // ----------------------------------------------------------
    {
        int wx = ZONE_TIME_W + MARGIN;

        // Ikona 48x48
        int icon_size = 96;
        int icon_x = wx;
        int icon_y = MARGIN + 4;
        ui_weather_icon(icon_x, icon_y, icon_size, w->icon);

        // Temperatura: np. "-4.2°C"
        char tstr[16];
        int temp_int  = (int)w->temp_c;
        int temp_frac = (int)(fabsf(w->temp_c - (float)temp_int) * 10.0f);
        snprintf(tstr, sizeof(tstr), "%d.%d\xC2\xB0""C", temp_int, temp_frac);

        int tscale = 6;
        int tx = wx;
        int ty = icon_y + icon_size;
        ui_text(tx, ty, tstr, tscale, 0);

        // Opis
        int desc_y = ty + 7*tscale + 6;
        ui_text_wrap(tx, desc_y, w->description, 2, ZONE_WEATHER_W - MARGIN*2, 0);


        // Miasto
        int city_y = desc_y + 46;
        ui_text(tx, city_y, w->city, 2, 0);

        ui_vline(ZONE_TIME_W + ZONE_WEATHER_W - 1, MARGIN, EPD_H - 2*MARGIN, 0);
    }

    // ----------------------------------------------------------
    // STREFA PRAWA: obrazek BMP
    // ----------------------------------------------------------
    {
        int bx0    = ZONE_TIME_W + ZONE_WEATHER_W;
        int avail_w = EPD_W - bx0;
        int avail_h = EPD_H;

        if (bmp_buf && bmp_w > 0 && bmp_h > 0) {
            int off_x = bx0 + (avail_w - bmp_w) / 2;
            int off_y = (avail_h - bmp_h) / 2;
            ui_bmp(off_x, off_y, bmp_w, bmp_h, bmp_buf);
        } else {
            // Placeholder
            ui_rect_border(bx0, 0, avail_w, avail_h, 0);
            for (int s = 0; s < avail_w; s++) {
                ui_px(bx0 + s, s * avail_h / avail_w, 0);
                ui_px(bx0 + s, avail_h - 1 - s * avail_h / avail_w, 0);
            }
        }
    }
}
